# Keil uVision project 框架式编程.uvproj, settings and files
target STC89C52 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 框架式编程 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\c_and_h
  asm include: ..\c_and_h
  group Source
    ./: STARTUP.A51
    ../c_and_h/: HC595_Driver.c main.c HC595_Driver.h
